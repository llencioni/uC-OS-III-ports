# Keil uVision project Keil-LPC2129.uvproj, settings and files
target Keil-LPC2129 (ARM-ADS)
  device: LPC2129/01 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Keil-LPC2129
  c flags: Optim=1
  c include: ..\..\App;..\..\Config;..\Keil-LPC2129;.\BSP;.\uC-CPU;..\..\uC-LIB;..\..\uCOS-III
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group App
    ../../App/: app.c includes.h
  group Config
    ../../Config/: app_cfg.h os_cfg.h cpu_cfg.h lib_cfg.h os_cfg_app.h
  group BSP
    ./BSP/: bsp.c bsp.h os_app_hooks.c os_app_hooks.h Startup.s os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC-CPU
    ./uC-CPU/: cpu.h cpu_c.c cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC-LIB
    ../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOS-III
    ../../uCOS-III/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
